# Repository lucanastasio/TunableFilter

File README.md:

# Tunable Filter with varactors
## Idea (our goal)
The idea of this project is the design of a tunable filter with variable resonance frequency. Achieving this would be possible using varactors. The varactors are used in place of the capacitors in resonators thanks to their abrupt juction that results in an high variation in capacitance with respect to the voltage applied across their terminals. So the varactor is the tuning component in this project. The use of this component will be explained in the following notes.

## Design specifications
The (approximate) design specifications used in the design of this filter are the following:

- ***Type of Filter:*** band-pass
- ***Type of Response:*** Chebyshev (equi-ripple)
- ***Order of the filter:*** Third Order
- ***Resonant frequency:***  (adjustable)
- ***Bandwitdh:***  (adjustable)
- ***Ports Impedances:*** 
- ***Ripple Level:***  (adjustable)

## Design of the ideal Filter
The project started with the design of the ideal pass-band filter in order to verify that all the specifications can be satisfied. For the design, the method used was ***Insertion Loss Method*** taking the low-pass Filter prototype and changing the series and shunt components in order to have a pass-band response. Below is the schematic of the ideal pass-band filter:

Formulas used in the first design stage:

- 
- 
- 
- 
- 
- 

where:

-  : band-pass prototype filter coefficients, calculate as a third order Chebyshev filter [unitless]
-  : fractional bandwidth [%]
-  : angular frequency [rad/s]

The above formulas take into account impedance scaling and frequency scaling since the low-pass prototype uses an angular frequency at the resonant frequency of  and a source impedance of .
The resonant frequency (hence the fractional bandwidth) is not specified at this point of the design, instead it's left as a parameter. Then simulation environment's tuner tool (AWR) allows sweeping the parameter in its range.

In order to set an arbitrary inductor value for the resonators, impedance inverters were used with a proper value of ***K*** (inverter parameter). The resonator inductor value is called  in the schematic and its value is not yet determined, it's again a tunable value in order to obtain the best value which can be found as an off-the-shelf component. Thus, in the schematic of the pass-band filter, 4 impedance inverters were added, as shown in the following image:

The resonator capacitor value is set by the equation:

The above equation gives the proper value of  for the desired resonat frequency.

Following are the formulas used to compute ***K*** parameters for each inverter:

- K for the impedence inverter at the source: 
- K for the second impedence inverter: 
- K for the third impedence inverter: 
- K for the impedence inverter at the load: 

where  is the source impedance,  is the bandwidth expressed in terms of angular frequency,  is the desired resonator inductance, and  are the band-pass filter prototype coefficients.

At this point impedance inverters are implemented as quarter-wave long transmission lines. The range of working frequencies spans from 0 to 1 GHz, so the physical length of the transmission lines results in an unfeasible dimension for a printed circuit board. To minimize board dimensions, the most reasonable choice is to implement the filter with lumped elements only, so an equivalent circuit for impedance inverters is required. For the 2 impedance inverters in the middle of the filter, the equivalent circuit is a T circuit composed of three capacitors where the shunt capacitor has a positive capacitance while the serires capacitors have a negative capacitance. Capacitors with negative capacitance are not physically possible but the use of this component is useful in the theoric design phase. Negative capacitors will be "absorbed" by the series with resonator capacitors, but only if the negative capacitors have a capacitance (in magnitude) greater than the resonator's one.
However, negative capacitances of impedance inverters at source and load ports are not "absorbed". To solve this problem another equivalent circuit is required for those two special cases, it consists of a shunt positive capacitor and only one series negative capacitor.
The schematic where all the impedance inverters are replaced with their respective equivalent circuits is shown in the figure:

The formulas used to calculate capacitor values are:

- Impedance inverter at the source: 
	- shunt capacitor 
	- series capacitor 
- Second impedance inverter:
	- all capacitors have the same value 
- Third impedance inverter:
	- all capacitors have the same value 
- Impedance inverter at the load: 
	- shunt capacitor 
	- series capacitor 

Thanks to the symmetry of the circuit one has that  and .

As a last step of the design of the ideal pass-band filter, negative capacitors are "absorbed" by positive capacitors of the resonators. The final circuit is the following:

Capacitances are calculated using the well-known formula for series capacitance, thus:

- 
- 
- 

As per the circuit symmetry, .
It may be noted that the plus sign in front of  and  is due to the fact that the minus sign is inclued in their formulas.

Frequency response at the test resonant frequency of 1GHz of the final design of the ideal filter (without varactor) is shown below for ripple levels of 0.5 dB and 3dB respectively:

## Adding tunable element: the varactor

## KiCad design PCB/Filter_PCB_4/Filter_PCB_4.kicad_pcb

Parts:
J1, J2: Conn_Coaxial; SMA_generic_EdgeMount

Connections:
/RF/RFin: J1.1 (In); also elsewhere on the board
/RF/RFout: J2.1 (In); also elsewhere on the board
GND: J1.2 (Ext), J2.2 (Ext); also elsewhere on the board

Schematic: DAC.sch

Parts:
C9: 4.7u; C_0603_1608Metric
C10: 100n; C_0603_1608Metric
J3: Conn_01x06_Male; PinHeader_2x03_P2.54mm_Vertical_SMD
L4: 180R; L_0603_1608Metric
U1: MCP4728; MSOP-10_3x3mm_P0.5mm

Connections:
/DAC/RDY: J3.6, U1.5
/DAC/SCL: J3.4, U1.2
/DAC/SDA: J3.3, U1.3
/DAC/~LDAC: J3.5, U1.4
/RF/V0: U1.6; also elsewhere on the board
/RF/V1: U1.7; also elsewhere on the board
/RF/V2: U1.8; also elsewhere on the board
/RF/V3: U1.9; also elsewhere on the board
GND: C9.2, C10.2, J3.1, U1.10; also elsewhere on the board
VDD: C9.1, J3.2, L4.2
VDDA: C10.1, L4.1, U1.1

Parts:
C1, C2: 100n; C_0603_1608Metric
D1, D2: BB202; D_SOD-523
R1: 100k; R_0603_1608Metric

Connections:
/RF/RFin: C1.1; also elsewhere on the board
/RF/V0: R1.1; also elsewhere on the board
/RF/inv0/Vd: C1.2, C2.1, D1.1 (K), D2.1 (K), R1.2
/RF/res0/In: C2.2; also elsewhere on the board
GND: D1.2 (A), D2.2 (A); also elsewhere on the board

Parts of its further copies:
C3, C4, C5, C6, C7, C8: 100n; C_0603_1608Metric
D3, D4, D5, D6, D7, D8: BB202; D_SOD-523
R4, R7, R10: 100k; R_0603_1608Metric

Connections of its further copies:
/RF/RFout: C8.2; also elsewhere on the board
/RF/V0: R10.1; also elsewhere on the board
/RF/V2: R4.1, R7.1; also elsewhere on the board
/RF/inv1/In: C3.1; also elsewhere on the board
/RF/inv1/Vd: C3.2, C4.1, D3.1 (K), D4.1 (K), R4.2
/RF/inv2/In: C5.1; also elsewhere on the board
/RF/inv2/Vd: C5.2, C6.1, D5.1 (K), D6.1 (K), R7.2
/RF/inv3/In: C7.1; also elsewhere on the board
/RF/inv3/Vd: C7.2, C8.1, D7.1 (K), D8.1 (K), R10.2
/RF/res1/In: C4.2; also elsewhere on the board
/RF/res2/In: C6.2; also elsewhere on the board
GND: D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A); also elsewhere on the board

Parts:
D9: BB202; D_SOD-523
L1: L0; Coilcraft_0603CS
R2, R3: 100k; R_0603_1608Metric

Connections:
/RF/V1: R2.1; also elsewhere on the board
/RF/inv1/In: D9.2 (A), R3.1; also elsewhere on the board
/RF/res0/In: L1.1; also elsewhere on the board
/RF/res0/Vd+: D9.1 (K), L1.2, R2.2
GND: R3.2; also elsewhere on the board

Parts of its further copies:
D10, D11: BB202; D_SOD-523
L2, L3: L0; Coilcraft_0603CS
R5, R6, R8, R9: 100k; R_0603_1608Metric

Connections of its further copies:
/RF/V1: R8.1; also elsewhere on the board
/RF/V3: R5.1; also elsewhere on the board
/RF/inv2/In: D10.2 (A), R6.1; also elsewhere on the board
/RF/inv3/In: D11.2 (A), R9.1; also elsewhere on the board
/RF/res1/In: L2.1; also elsewhere on the board
/RF/res1/Vd+: D10.1 (K), L2.2, R5.2
/RF/res2/In: L3.1; also elsewhere on the board
/RF/res2/Vd+: D11.1 (K), L3.2, R8.2
GND: R6.2, R9.2; also elsewhere on the board

Board: 4 copper layers, 32.4 x 8.9 mm, 39 parts (5 on the bottom side), 26 nets.

## KiCad design PCB/USB_I2C/USB_I2C0.kicad_pcb

Parts:
C10, C11: 4.7u; C_0603_1608Metric
J1: Conn_01x06_Male; PinHeader_2x03_P2.54mm_Vertical_SMD
J4: USB_B_Micro; USB_Micro-B_Molex_47346-0001
RN1: 1k; R_Array_Convex_4x0603
U1: CP2112; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
+3V3: C11.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), U1.5 (VIO), U1.6 (VDD)
/D+: J4.3 (D+), U1.3 (D+)
/D-: J4.2 (D-), U1.4 (D-)
/RDY: J1.6, RN1.1 (R1.1), U1.20 (GPIO.3)
/SCL: J1.4, RN1.4 (R4.1), U1.24 (SCL)
/SDA: J1.3, RN1.3 (R3.1), U1.1 (SDA)
/~LDAC: J1.5, RN1.2 (R2.1), U1.21 (GPIO.2)
GND: C10.2, C11.2, J1.1, J4.5 (GND), J4.6 (Shield), U1.2 (GND), U1.25 (GND)
VBUS: C10.1, J1.2, J4.1 (VBUS), U1.7 (REGIN), U1.8 (VBUS)

Board: 2 copper layers, 6 parts (0 on the bottom side), 9 nets, no tracks yet.

## KiCad design Jig_Varactor/Jig_Varactor.kicad_pcb

Parts:
C1: CAP; C_0603_1608Metric
D1: D_Capacitance; D_SOD-523
J1: Conn_Coaxial; SMA_generic_EdgeMount
J2: Conn_02x01; PinHeader_2x01_P2.54mm_Vertical
R1, R2: R; R_0603_1608Metric

Connections:
GND: D1.2 (A), J1.2 (Ext), R2.2
unnamed: C1.1, J1.1 (In)
unnamed: C1.2, D1.1 (K), R1.2
unnamed: J2.1, R2.1
unnamed: J2.2, R1.1

Board: 2 copper layers, 14.0 x 7.6 mm, 6 parts (1 on the bottom side), 5 nets.

## KiCad design Filter_PCB/Filter_PCB.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: C; C_0603_1608Metric
D1, D2, D3, D4: D_Capacitance_ALT; D_SOD-523
J1: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J2, J3: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
L1, L2, L3, L4: L; L_0603_1608Metric
R1, R2, R3, R4, R5, R6: R; R_0603_1608Metric
U1: MCP4728; MSOP-10_3x3mm_P0.5mm

Connections:
/RDY: J1.2, U1.5 (RDY/~BSY)
/SCL: J1.5, U1.2 (SCL)
/SDA: J1.4, U1.3 (SDA)
/VA: R1.1, U1.6 (VOUTA)
/VB: R3.1, U1.7 (VOUTB)
/VC: R4.1, U1.8 (VOUTC)
/VD: R6.1, U1.9 (VOUTD)
/~LDAC: J1.3, U1.4 (~LDAC)
GND: C2.2, C3.2, D2.2 (A), D3.2 (A), J1.1, J2.2 (Ext), J3.2 (Ext), R2.2, R5.2, U1.10 (VSS)
unnamed: C1.1, J2.1 (In)
unnamed: C1.2, D1.1 (K), R1.2
unnamed: C4.1, D2.1 (K), L3.1, R3.2
unnamed: C4.2, L2.2
unnamed: C5.1, C6.1, D3.1 (K), R4.2
unnamed: C5.2, L3.2
unnamed: C6.2, L4.2
unnamed: C7.1, J3.1 (In)
unnamed: C7.2, D4.1 (K), R6.2
unnamed: D1.2 (A), L2.1, R2.1
unnamed: D4.2 (A), L4.1, R5.1
VDD: C3.1, J1.6, L1.2
VDDA: C2.1, L1.1, U1.1 (VDD)

Board: 2 copper layers, 43.8 x 15.2 mm, 25 parts (0 on the bottom side), 22 nets.

## Commit log

2019-12-12 Modifiche file AWR
2019-12-12 pulizia
2019-12-12 componenti reali modifica
2019-12-12 Modifica filtro AWR
2019-12-15 MCP4728
2019-12-16 board + modified AWR
2019-12-16 KiCad gitignore
2019-12-16 footprint replacement
2019-12-17 modifche AWR + PCB
2019-12-17 Chebyshev
2019-12-17 various
2019-12-18 New cheby with inverter
2019-12-19 varactor added
2019-12-23 moved varactor
2019-12-23 varactor version added in tunable filter file
2019-12-27 aggiunti condensatori di disaccoppiamento
    Non c'è nessuna variazione della risposta in frequenza, i condensatori di disaccoppiamento sono di 10 nano
2019-12-27 file di tognolatti + funzione per tensione varactor nel file tunable filter
2019-12-27 new ideal reference filter
2019-12-27 real varactor tuning
2019-12-27 curve fitting
2019-12-28 jig varactor added
2019-12-28 varactor test jig
2019-12-28 gerbers
2019-12-29 Aggiunto schematico con induttori reali
2019-12-29 Rendered TeX expressions in 7ad5ce78f3432c6a9848719e0f579559e23e3d94
2019-12-30 README.tex aggiornato.
    Inserito screenshoot di AWR come immagine. In seguito la sostituirò con uno schematico fatt meglio.
2019-12-30 Rendered TeX expressions in 856e794b090600827bbd69b0cffe2312c32e80b8
2019-12-30 added BB202
2019-12-30 Rendered TeX expressions in 5fb73a6c4df12c4cd10376899375e1d98bda0095, 97cb12906f7d0c6d87a3f7aa6f4c50664cb6d67c
2019-12-30 readme correction
2019-12-30 Rendered TeX expressions in 232dabe9c5bb20d57efda0dfba8cbc281ae405cc, d29250c3c87889fea1c6a9d9f55833a4c94c0479
2019-12-31 first usable gui
2020-01-02 BB202 extraction
2020-01-02 Aggiunto modello SPICE varactor + setup di misura
    Ho aggiunto una cartella con il modello spice del varactor implementato come subcircuit. La validità di tale modello è stata testata con la curva C vs V del varactor SMV1235 della skyworks. Inoltre n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
2020-01-02 Aggiornato il file tunable_filter
    Aggiunta la versione con varactor BB202 e anche la netlist del BB181. Bisogna ricontrollare la funzone ricavata per il BB202.
2020-01-03 optimized BB202 model
2020-01-03 readme: completata parte filtro ideale
2020-01-03 Rendered TeX expressions in 772d6eb5afd7415d3984543d8a7ef150a27d598f, 5b8778e1be123f29ce477fbe933367c17d8f132e
2020-01-03 Rendered TeX expressions in aa47af1de9a8767e124ade07895abfeb04b42bc6
2020-01-03 filter with BB202 model
2020-01-06 Aggiunto modello SMV1705 (Skyworks) nel file component characterization
2020-01-07 Filter with SMV1705 and readme
    -Aggiunto schematico filtro tunabile con varactor SMV1705
    -Aggiornato README con risposta in frequenza (solo S21)
2020-01-07 Rendered TeX expressions in a5861b20f900a971a0be644297ac0e3bb3c7cd0d
2020-01-07 Rendered TeX expressions in 6cfb9ab0d25b35ada80269ea94a8ade4dbb818a1
2020-01-07 Rendered TeX expressions in 386c28ff8d5d44698234223c18ce0e634cdce78a, 703b2b6675cf88ae96c41ffe37f6e03a0fad7e79
2020-01-08 formulas
2020-01-08 Rendered TeX expressions in 7789364d4dd4298754a59fffcea5ba228768c3e8
2020-01-08 Rendered TeX expressions in 65ca4d83a26b05af1f4690680b563a69b9ed50e1, 9c8079c41ec19b814f5d357a5cc8815e6a7269d2, 23327e2f8f8fc1eff03bbd7bfb9f794141f83a26
2020-01-08 Rendered TeX expressions in 7f62ff5583a6e8dbdf7247389b10c33fe8432215
2020-01-08 RF layout
2020-01-08 filter corrections
2020-01-08 PCB layout
2020-01-09 aggiunto file prova con componenti reali
2020-01-09 Lp compensation
2020-01-10 parallel varactor
2020-01-10 Create Tunable_filter_final.emp
    - aggiunti varactor parallelo per versione con SMV1705
    - tutti i circuiti nel file sono a componenti reali
    - aggiunta configurazione back to back per ridurre le capacità dei varactor serie
2020-01-10 Create sq_spring.pdf
    Datasheet nuovo induttore coilcraft
2020-01-14 btob pcb
2020-01-14 PCB updated
    resistori 0603 sostituiti da resistori 0402
2020-02-04 gui i2c adapter
2020-02-04 pcb4 board update
2020-02-04 misure nanoVNA BB181
2020-02-12 gerber
2020-02-19 filter gui
